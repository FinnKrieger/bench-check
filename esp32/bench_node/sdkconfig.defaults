## esp32/bench_node/sdkconfig.defaults
```kconfig
CONFIG_IDF_TARGET="esp32s3"
CONFIG_MQTT_PROTOCOL_311=y
CONFIG_ESP_MAIN_TASK_STACK_SIZE=4096
```
